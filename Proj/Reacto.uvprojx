# Keil uVision project Reacto.uvprojx, settings and files
target REACTO (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Reacto +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,
  c include: ..\Libraries\CMSIS\startup;..\Libraries\CMSIS;..\Libraries\FWLIB\src;..\Libraries\FWLIB\inc;..\Libraries;..\User;..\User\SYS;..\User\OLED;..\User\SHOW;..\User\DELAY;..\User\USART;..\User\LED;..\User\MPU6050;..\User\ENCODER;..\User\TIMER;..\User\MOTOR;..\User\CONTROL;..\User\FILTER;..\User\EXTI;..\User\UPPER;..\User\ADC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Libraries/: stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
  group FWLIB
    ../Libraries/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c
    ../User/SYS/: sys.c
    ../User/DELAY/: delay.c
    ../User/USART/: usart.c usart2.c
    ../User/LED/: led.c
  group OLED
    ../User/OLED/: oled.c
    ../User/SHOW/: show.c
  group MPU6050
    ../User/MPU6050/: mpu6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_i2c.c
  group EM
    ../User/ENCODER/: encoder.c
    ../User/TIMER/: timer.c
    ../User/MOTOR/: motor.c
    ../User/CONTROL/: control.c
    ../User/FILTER/: filter.c
    ../User/EXTI/: exti.c
    ../User/UPPER/: DataScope_DP.C
    ../User/ADC/: adc.c
  group Doc
    ../Doc/: book.txt
